# Keil uVision project project.uvprojx, settings and files
target rtthread (6230000::V6.23::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER, STM32H743xx, __STDC_LIMIT_MACROS, __RTTHREAD__, __PERF_CNT_USE_RTOS__, RT_USING_ARMLIBC, __perf_counter_printf__=rt_kprintf, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications\motor;board\ports;rt-thread\components\utilities\libadt\hashmap;rt-thread\components\utilities\ulog;packages\freemodbus-latest\modbus\rtu;applications\chassis;board\CubeMX_Config\Inc;rt-thread\components\drivers\include;rt-thread\components\finsh;packages\perf_counter-v2.2.4.1;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\libc\posix\io\epoll;applications;rt-thread\components\drivers\usb\usbdevice;rt-thread\components\libc\posix\ipc;applications\commands;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;libraries\HAL_Drivers;packages\freemodbus-latest\modbus\tcp;rt-thread\components\utilities\libadt\bitmap;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\ktime;rt-thread\libcpu\arm\common;rt-thread\components\drivers\ktime\inc;rt-thread\libcpu\arm\cortex-m7;packages\FlashDB-v1.1.2\inc;rt-thread\components\utilities\libadt\uthash;packages\freemodbus-latest\modbus\ascii;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;board;libraries\HAL_Drivers\drivers\drv_flash;packages\pcf8574-latest;applications\meArm;rt-thread\components\libc\cplusplus;rt-thread\components\drivers\include;rt-thread\components\fal\inc;rt-thread\components\drivers\include;packages\APID-latest\src;packages\freemodbus-latest\modbus\include;packages\get_irq_priority-latest;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\delay;rt-thread\components\libc\posix\io\eventfd;packages\rs485-latest\inc;rt-thread\components\drivers\include;rt-thread\components\utilities\libadt\avl;rt-thread\components\utilities\libadt\ref;rt-thread\components\libc\posix\io\stdio;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\libc\cplusplus\os;libraries\HAL_Drivers\drivers;rt-thread\components\drivers\spi;packages\FlexibleButton-latest;rt-thread\components\libc\compilers\common\extension;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;rt-thread\components\libc\posix\pthreads;libraries\HAL_Drivers\drivers\config;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\posix\io\poll;packages\freemodbus-latest\port;rt-thread\components\libc\cplusplus\cpp11\armclang;.;packages\cpu_usage-latest;rt-thread\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group apid
    packages/APID-latest/src/: apid_auto_tune_ZNmode.c apid.c apid_exfunc.c apid_ex_fuzzy.c
  group Applications
    applications/: laser_gimbal_test.c usart_dataparsing.c laser_gimbal_vision_tracker.c hipnuc_dec.c pwm.c laser_gimbal_vision_test.c key.c wireless_communicate.c ms4010_multi_test.c laser_gimbal.c ms4010_simple_test.c main.c drv_ms4010.c SM2924_Modbus.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/cpp11/armclang/: clock.cpp condvar.cpp miscellaneous.cpp mutex.cpp thread.cpp
    rt-thread/components/libc/cplusplus/cpp11/: atomic_8.c emutls.c thread_local_impl.cpp
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
    rt-thread/components/libc/cplusplus/os/: cxx_Mutex.cpp cxx_Semaphore.cpp cxx_Thread.cpp
  group cpu_usage
    packages/cpu_usage-latest/: cpu_usage.c cpu_usage_cmd.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c rt_drv_pwm.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c drv_mpu.c
    board/ports/: drv_qspi_flash.c
    libraries/HAL_Drivers/drivers/: drv_adc.c drv_gpio.c drv_pwm.c drv_qspi.c drv_spi.c drv_tim.c drv_usart_v2.c
    libraries/HAL_Drivers/drivers/drv_flash/: drv_flash_h7.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group Fal
    rt-thread/components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c msh_parse.c cmd.c
  group FlashDB
    packages/FlashDB-v1.1.2/samples/: kvdb_type_blob_sample.c kvdb_type_string_sample.c kvdb_basic_sample.c tsdb_sample.c
    packages/FlashDB-v1.1.2/src/: fdb_cmd.c fdb_utils.c fdb_file.c fdb_kvdb.c fdb.c fdb_tsdb.c
  group flex_button
    packages/FlexibleButton-latest/: flexible_button.c
  group FreeModbus
    packages/freemodbus-latest/modbus/functions/: mbfuncother.c mbfunccoils_m.c mbfuncdisc_m.c mbfuncinput_m.c mbfuncdiag.c mbutils.c mbfuncholding_m.c
    packages/freemodbus-latest/port/: portevent_m.c portserial_m.c porttimer_m.c user_mb_app_m.c port.c
    packages/freemodbus-latest/modbus/: mb_m.c
    packages/freemodbus-latest/samples/: sample_mb_master.c
    packages/freemodbus-latest/modbus/rtu/: mbcrc.c mbrtu_m.c
  group get_irq_priority
    packages/get_irq_priority-latest/src/: get_irq.c
  group Kernel
    packages/rt_memcpy_cm-latest/: rt_memcpy_rvds.S
    rt-thread/src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group ktime
    rt-thread/components/drivers/ktime/src/: cputimer.c boottime.c hrtimer.c
  group LIBADT
    rt-thread/components/utilities/libadt/avl/: avl.c
  group libcpu
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_sram.c stm32h7xx_hal_spi.c stm32h7xx_hal_adc.c stm32h7xx_hal_dma.c stm32h7xx_hal_flash.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_i2c.c stm32h7xx_hal_cryp.c stm32h7xx_hal.c stm32h7xx_hal_mdma.c stm32h7xx_hal_qspi.c stm32h7xx_hal_hcd.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_crc.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_tim.c stm32h7xx_hal_pcd.c stm32h7xx_hal_lptim.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_pwr.c stm32h7xx_hal_cec.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_adc_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group pcf8574
    packages/pcf8574-latest/: pcf8574.c
  group perf_counter
    packages/perf_counter-v2.2.4.1/: perf_counter.c
    packages/perf_counter-v2.2.4.1/os/: perf_os_patch_rt_thread.c
  group POSIX
    rt-thread/components/libc/posix/delay/: delay.c
    rt-thread/components/libc/posix/io/stdio/: stdio.c
    rt-thread/components/libc/posix/pthreads/: pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c
  group rs485
    packages/rs485-latest/src/: rs485_sample_master.c rs485_test.c rs485_sample_slave.c rs485.c rs485_dev.c
  group rt_kprintf
    packages/rt_kprintf_threadsafe-latest/: rt_kprintf.c
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group rt_usbd
    rt-thread/components/drivers/usb/usbdevice/core/: usbdevice.c usbdevice_core.c
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
